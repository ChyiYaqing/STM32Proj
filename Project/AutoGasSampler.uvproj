# Keil uVision project AutoGasSampler.uvproj, settings and files
target AutoGasSampler (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: AutoGasSampler +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\System;..\Lib\inc;..\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group System
    ../System/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group User
    ../User/: main.c common.c
  group Lib
    ../Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_tim.c
  group Asm
    ../Asm/: startup_stm32f10x_hd.s
  group Driver
    ../Driver/: stm_sys.c stm_usart.c stm_gc.c stm_led.c stm_mfc.c stm_timer.c stm_ds18b20.c stm_tc.c stm_valve.c stm_pc.c stm_pump.c
